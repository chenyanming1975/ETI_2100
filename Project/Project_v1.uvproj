# Keil uVision project Project_v1.uvproj, settings and files
target Project_v1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC100RE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Project_v1 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\CMSIS\CM0\CoreSupport;..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\Library\inc;..\User\inc;C:\Keil\ARM\BIN
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ../User/src/: Sys_Initial.c Main.c Timer_isr.c Uart_APP.c Lcd_disp_APP.c Led_driver_APP.c Key_scan_APP.c Spi_flash_APP.c RTC_APP.C Buzz_BL_APP.c Pwm_APP.c Opration_finc.c SD_APP.c Program_updata_App.c
    ./: 接口说明文档.txt
  group Library files
    ../Library/src/: DrvUART.c DrvGPIO.c DrvI2C.c DrvPDMA.c DrvSPI.c DrvSYS.c DrvPWM.c retarget.c DrvFMC.c
